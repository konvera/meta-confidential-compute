SRC_URI += "file://fragment.cfg"
FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"
